# Copyright 2023-2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359"

SRC_URI[imx95.sha256sum] = "8b33ca53bd2692ba92fe928c42d0ec75f1abd3f33879f71660efca9983e9eb88"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"

