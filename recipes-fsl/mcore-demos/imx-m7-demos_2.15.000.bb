# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

SRC_URI[imx95.md5sum] = "572b54c7255faa020612261462bdd96b"
SRC_URI[imx95.sha256sum] = "118ea2248d7fd8a48412855fc19ff6f37f4e09e6d387dfdd458bb9a19d6192c6"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"
