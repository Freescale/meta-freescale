# Copyright 2017-2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx8mm-nxp-bsp = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

SRC_URI[imx8mm.md5sum] = "8db99da9efe8a5409a246c8a63d418dc"
SRC_URI[imx8mm.sha256sum] = "8269d7461efcdba0b8c3e684df8b45c2d8ace3fdf426b81bdfb46855a1577987"

COMPATIBLE_MACHINE = "(mx8mm-nxp-bsp)"
