# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx93-nxp-bsp = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"


SRC_URI[imx93.md5sum] = "3f420c28fdc159ecd5148a931a5ff02c"
SRC_URI[imx93.sha256sum] = "31f6e8b08edb677614e65b11bbcc796218691fe746b84ec2503b8a5060d69ef2"

COMPATIBLE_MACHINE = "(mx93-nxp-bsp)"
