# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "9a7d2eae3e9f4884b06fda42e5ec690a8a10bb0174ac5c695c21b4aefb7d4760"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
