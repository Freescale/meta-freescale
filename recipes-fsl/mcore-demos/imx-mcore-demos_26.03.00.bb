# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "408e94e64b8e94d243737e0c068459036273a2ca384b63b893696c77d69c2807"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
