# Copyright 2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "52acc5cb421ae98b9b496512035f1635be7238c2f15178f62277269e4744b95a"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
