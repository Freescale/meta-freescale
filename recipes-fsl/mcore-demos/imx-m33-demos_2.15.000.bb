# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx93-nxp-bsp = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

SRC_URI[imx93.md5sum] = "2fad663ff63d273a2cb775e06db9eedc"
SRC_URI[imx93.sha256sum] = "257066cbd57add127fae15da72f12f1cf6a847ff300e7b4ac63f507693898dfa"

COMPATIBLE_MACHINE = "(mx93-nxp-bsp)"
