# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=ef4f968b9dae8ba406390cd617c2301d"

SRC_URI[imx943.sha256sum] = "f4b4e35f28885ed6e33f0375857f4d3c96e9d7d5ca9af315dae0b07a1cfb2d8f"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
