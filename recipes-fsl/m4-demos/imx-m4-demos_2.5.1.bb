# Copyright 2019 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-m4-demos-2.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=80c0478f4339af024519b3723023fe28"

SRC_URI[imx7ulp.md5sum] = "21c6442419a2de3073b8631a2d93e494"
SRC_URI[imx7ulp.sha256sum] = "f65ee3516a10da93724e9cf111323ca809f9b93782358de798cd185d56590a29"

COMPATIBLE_MACHINE = "(mx7ulp)"
