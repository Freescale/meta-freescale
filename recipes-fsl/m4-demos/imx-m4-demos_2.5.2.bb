# Copyright 2017-2019 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-m4-demos-2.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=80c0478f4339af024519b3723023fe28"

SRC_URI[imx8qm.md5sum] = "6423c4c60412b509b6d7537ce1a3fd44"
SRC_URI[imx8qm.sha256sum] = "cf430d4a111370c021435e864666d34fae4c4242907c195aad0c46c48073f78f"

SRC_URI[imx8qx.md5sum] = "fe2e5c9513faac946d29e5904bf792d9"
SRC_URI[imx8qx.sha256sum] = "151c6a578f6ae5a09b378015116061875047e4f3b6264e4becc80276621893b1"

COMPATIBLE_MACHINE = "(mx8qm|mx8qxp)"
