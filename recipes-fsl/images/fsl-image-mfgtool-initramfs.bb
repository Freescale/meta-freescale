# Copyright (C) 2014 O.S. Systems Software LTDA.

SUMMARY = "Manufacturing Tool (mfg-tool) production initramfs image"
DESCRIPTION = "Small image to be used with Manufacturing Tool \
               (mfg-tool) in a production environment."
SECTION = "console/utils"

LICENSE = "MIT"

inherit mfgtool-initramfs-image
