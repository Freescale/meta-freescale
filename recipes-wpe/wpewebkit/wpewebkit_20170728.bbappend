# iMX8/gst 1.12 - update soup gst plugin
RDEPS_VIDEO_remove_imx8mqevk = " gstreamer1.0-plugins-good-souphttpsrc"
RDEPS_VIDEO_append_imx8mqevk = " gstreamer1.0-plugins-good-soup"
