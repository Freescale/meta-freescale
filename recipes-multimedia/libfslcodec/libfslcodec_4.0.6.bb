# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "03cf5f5ad650bcebbf5efaf03442b9cc"
SRC_URI[sha256sum] = "cdf6b0885d361f1db3c872f1c273a0ed348a50a729cb3114605b19654397d7ad"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
