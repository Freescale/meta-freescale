# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "462fb27b20cd7df56a49b9e7d6b7c8b4"
SRC_URI[sha256sum] = "544ffc5989bce18ca50c7a826cc03370b1cf8455335e4291ef0c0779b4c33de0"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
