# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "14de0ca4af46a5b7a597fc172072adbe"
SRC_URI[sha256sum] = "de1251286ebbc1541452f2f70fbd73e42c58f95630d65d1f9aaabf10a6caa38f"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
