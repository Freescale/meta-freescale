# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "8c3f82b24ed52d0039f8e7d6d8b93cad"
SRC_URI[sha256sum] = "495f2ce954144436b500156859b1cf4381a27e04f7c7a1d035480f8a738d4c84"

COMPATIBLE_MACHINE = "(mx6|mx7)"
