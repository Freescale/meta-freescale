# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "9538df4dc416e12ff13fdf12ddbf3684"
SRC_URI[sha256sum] = "a04621783c84a9776216caff9563c7f840fddd584b0b2d27738d6ca6d2c77f32"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
