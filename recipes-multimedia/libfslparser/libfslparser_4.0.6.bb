# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "efc2e5a8ce98b2977962527470308b07"
SRC_URI[sha256sum] = "d5a2277f9b4db35ec13eb53676d6b8d0b44a854a82dcd4b8e702b927fb713cb6"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
