# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "d1d0a2cff6cec3f157934034021ccf87"
SRC_URI[sha256sum] = "e7c248e64db03c3ddd84f50ae408e560f8f5819e58c487a5dec5141bc384ae83"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
