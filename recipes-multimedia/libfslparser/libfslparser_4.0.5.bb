# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "033209c9b91c6876187259686b7a449b"
SRC_URI[sha256sum] = "e7b28c398d320af195dc15273a3cebe6b381893359118093fac75ab87cf1afb1"

COMPATIBLE_MACHINE = "(mx6|mx7)"
