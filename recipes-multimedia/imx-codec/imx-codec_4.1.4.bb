# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

SRC_URI[md5sum] = "46e2004889fcdedbf259613f0046a7a1"
SRC_URI[sha256sum] = "98fe71cb44f7e858c64c5eda81741ed02f40afaadc3d4ed1e693c7d1e684b81d"

COMPATIBLE_MACHINE = "(mx6|mx7)"
