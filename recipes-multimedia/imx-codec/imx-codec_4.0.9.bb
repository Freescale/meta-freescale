# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

SRC_URI[md5sum] = "bcf54698af6f52958b36e34dcbd9fcd1"
SRC_URI[sha256sum] = "62bda182143cde9743cba0eb2a1c315a53cb434294605742f9fc364219958888"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
