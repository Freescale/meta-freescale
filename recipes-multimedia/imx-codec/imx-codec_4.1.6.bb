# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

SRC_URI[md5sum] = "041adb904c50f1cee681b7f6d948e853"
SRC_URI[sha256sum] = "1ed94a01fb47b50ec488dc8dfe96e874ae8270af5e1161f693a8bbe09e507abf"

COMPATIBLE_MACHINE = "(mx6|mx7)"
