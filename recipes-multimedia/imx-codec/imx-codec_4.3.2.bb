# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

SRC_URI[md5sum] = "5c09ad91c8586128029ecfb9f2072a5b"
SRC_URI[sha256sum] = "d7ef3beda185763ddacefb4dd5ff99fc9554d94389b88f224beaca28421a7e14"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
