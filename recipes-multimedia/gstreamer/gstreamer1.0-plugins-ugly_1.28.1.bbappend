PACKAGECONFIG:remove = "a52dec mpeg2dec"
