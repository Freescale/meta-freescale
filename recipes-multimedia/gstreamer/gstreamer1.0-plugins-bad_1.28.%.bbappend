PACKAGECONFIG:append:use-mainline-bsp = " v4l2codecs"
