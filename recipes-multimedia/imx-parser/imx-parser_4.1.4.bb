# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[md5sum] = "fe8e9367887bf4a30decc6d0368ffbe9"
SRC_URI[sha256sum] = "d3a03e60780bbbd0c92932f60bd34d2fe14ffecf6aa6b810723c3edf798cad1f"

COMPATIBLE_MACHINE = "(mx6|mx7)"
