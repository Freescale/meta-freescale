# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[md5sum] = "6717799abce0dc5918db8d3fd0e39184"
SRC_URI[sha256sum] = "36d3ae7285f3a83a87abf680b8a52b3c07df869d2443de844fb5f0ff528ca862"

COMPATIBLE_MACHINE = "(mx6|mx7)"
