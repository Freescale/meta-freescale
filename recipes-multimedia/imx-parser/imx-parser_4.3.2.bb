# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[md5sum] = "c69669d18ab77fa62fe1dc4fd0eea9e4"
SRC_URI[sha256sum] = "2cab49758fb5b27e0735379ab98ac43787195c4d73aac440f24ba3fd1c252e32"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
