# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[md5sum] = "184687baede96fe3919196c3f91d907c"
SRC_URI[sha256sum] = "1bec0101843db2e95d61e3dbe9e35172d874e54be19cc5d8bf72a735d5e3236f"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
