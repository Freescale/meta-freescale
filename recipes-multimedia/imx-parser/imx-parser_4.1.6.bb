# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[md5sum] = "393bfe9e43d58585977199049dbcb732"
SRC_URI[sha256sum] = "ed0f8cafc67751d4b8fcf45ffe481a3020330d91294de8bf618dacc75ba02f8e"

COMPATIBLE_MACHINE = "(mx6|mx7)"
