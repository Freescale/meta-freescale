# Copyright (C) 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-parser.inc

SRC_URI[sha256sum] = "1ca42d0ee4f0eac0296876976a89e5e6adff8af538f28b355487c169816144cd"
IMX_SRCREV_ABBREV = "ed69753"
