require recipes-kernel/linux/linux-qoriq-sdk.inc

SRC_URI = "git://git.freescale.com/ppc/sdk/linux.git;nobranch=1"
SRCREV = "c29fe1a733308cbe592b3af054a97be1b91cf2dd"

