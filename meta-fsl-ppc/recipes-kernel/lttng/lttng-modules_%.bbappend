inherit qoriq_build_64bit_kernel

