FILEXTRAPATHS_prepend_fsl := "${THISDIR}/files:"

PR_fsl .= "+${DISTRO}.0"

