FILESEXTRAPATHS_prepend_fsl := "${THISDIR}/files:"

PR_fsl .= "+${DISTRO}.1"
