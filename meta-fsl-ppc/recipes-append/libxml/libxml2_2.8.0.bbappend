EXTRA_OECONF += "--with-fexceptions"

PR .= "+${DISTRO}.0"
