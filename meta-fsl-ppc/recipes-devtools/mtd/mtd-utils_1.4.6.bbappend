FILESEXTRAPATHS_prepend := "${THISDIR}/mtd-utils-1.4.6:"

SRC_URI += "file://mtd-utils-fix-corrupt-cleanmarker-with-flash_erase--j-command.patch"
