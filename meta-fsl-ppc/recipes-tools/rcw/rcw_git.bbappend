# we call this git since it's ongoing development
# once it's on git.freescale.com it needs to be updated
# to the correct version there
PV = "git"

SRC_URI = "git://git.am.freescale.net/gitolite/sdk/rcw.git"
SRCREV = "${AUTOREV}"

