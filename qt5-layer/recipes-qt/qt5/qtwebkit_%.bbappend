FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-to-match-the-uniform-precision-qualifiers-in-ver.patch"

