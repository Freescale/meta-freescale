# Append path for freescale layer to include bsp xorg.conf 
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
