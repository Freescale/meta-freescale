# Append path for freescale layer to include bsp pointercal.xinput
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
