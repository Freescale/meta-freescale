# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "200ee64d8b922bc2f8718e5d0af01539"
SRC_URI[sha256sum] = "b53e6e2f9b47678bb2f8ad107fea5bd70d111b085e03d246fbaafd1f6cc2dc3a"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
