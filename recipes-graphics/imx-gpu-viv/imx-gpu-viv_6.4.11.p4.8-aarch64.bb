require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef4f968b9dae8ba406390cd617c2301d"

IMX_SRCREV_ABBREV = "ec0a6bb"

SRC_URI[sha256sum] = "ab2ee837a54f0cc206d23edf19ba904a3884dcaa17101c05324b59472a11e705"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
