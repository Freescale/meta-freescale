# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "a5c945615c8145ca4aa3d9a69bfdd2f7"
SRC_URI[sha256sum] = "1324b1aaf190110b80ad9a6f6533f4f50dce9e9ab8d49d8503f59764b151d219"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
