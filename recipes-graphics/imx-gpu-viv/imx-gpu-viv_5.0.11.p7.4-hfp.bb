# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

SRC_URI[md5sum] = "d348def4c050e215efe970828752e5b9"
SRC_URI[sha256sum] = "b80838104f2f2e3b0baf2f1aacdca263c1c92589ce919b3be40aaad23f686b7f"

PACKAGE_FP_TYPE = "hardfp"
