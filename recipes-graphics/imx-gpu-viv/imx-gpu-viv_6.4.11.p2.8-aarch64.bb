require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

IMX_SRCREV_ABBREV = "95408a4"

SRC_URI[sha256sum] = "aadfcf558d07da253a57acfd5aa4ca41d4c8195f04324d0c2f6746f6f18c5a46"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
