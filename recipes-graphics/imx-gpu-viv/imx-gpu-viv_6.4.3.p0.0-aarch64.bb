require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "db4c88a19d0c1f7ec2788531822f9144"
SRC_URI[sha256sum] = "b3bd03288106daf3a62d2301d09569292ef6a5c74c761cfa4e41dad85e4bf547"

COMPATIBLE_MACHINE = "(mx8)"
