require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "7c2f504897e6b4495433546ab7d27912"
SRC_URI[sha256sum] = "45852a5c3c61a9215a2ffb7387a6e1cce7ddac6f12513fc77459ad7e1f1b3a27"

COMPATIBLE_MACHINE = "(mx8)"
