require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "612a9bfc0663da7aeee0c4d277acffb7"
SRC_URI[sha256sum] = "ea9ecb151d2dcdaeff1184e5de097bb35d53d8747a743a96d4cfd4a8a3814752"

COMPATIBLE_MACHINE = "(mx8)"
