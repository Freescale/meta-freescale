require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=10c0fda810c63b052409b15a5445671a"

IMX_SRCREV_ABBREV = "bc7b6a2"

SRC_URI[md5sum] = "d921b6daf89eba252b0b5b59abe0d690"
SRC_URI[sha256sum] = "cf6e42c9c9a903cd933b767d411131390d237a4b92ecad579db57d54538707f3"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
