require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "ff63b1fb889ae9fe41f0cca14d62b69c"
SRC_URI[sha256sum] = "003c30baefb1655790b475c3cdfa5cefbf81ea89ef37c6649b64f151dd23a52e"

COMPATIBLE_MACHINE = "(mx8)"
