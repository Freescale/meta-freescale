require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=63a38e9f392d8813d6f1f4d0d6fbe657"

IMX_SRCREV_ABBREV = "1e0c396"

SRC_URI[md5sum] = "34b1a4de2fc9fba8b15fc1f204096603"
SRC_URI[sha256sum] = "d5904cbbe33a3c1160e9cd15c44d78df25d0dbd7b251add796673af53d3046f6"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
