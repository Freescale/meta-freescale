require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "72a212a1bd8102718f8b03d935f1dcbc"
SRC_URI[sha256sum] = "0505620c3851a980d2e08fee4b4fcd06eff92efac02d1646924bea86e4384ad4"

COMPATIBLE_MACHINE = "(mx8)"
