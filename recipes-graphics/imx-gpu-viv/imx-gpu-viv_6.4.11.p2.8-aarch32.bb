require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

IMX_SRCREV_ABBREV = "95408a4"

SRC_URI[sha256sum] = "c479c98e83866a7e95e5a6ae29b21ae41f9599326298d9a1debf009cac6e9406"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
