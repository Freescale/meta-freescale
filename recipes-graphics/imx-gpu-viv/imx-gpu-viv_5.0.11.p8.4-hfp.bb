# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

SRC_URI[md5sum] = "d5400c6c54f6601eb34e442ee8fd1863"
SRC_URI[sha256sum] = "8f79ce562d8ac1efb0a2af403b405541f98c55ae1631a18a3d7fad3224dfb44b"
