require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "a937571f6ecf85bdff1dfb3b6c834ed0"
SRC_URI[sha256sum] = "1eb4ebe2fa11d8fb7beb8fc7046bb57093fd416d0a401608d78cd48b65624fcd"

COMPATIBLE_MACHINE = "(mx8)"
