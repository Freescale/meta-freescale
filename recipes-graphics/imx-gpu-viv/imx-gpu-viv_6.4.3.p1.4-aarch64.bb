require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "2493f1264458ac13572cf328ae78f280"
SRC_URI[sha256sum] = "5f1579ac846dad3464e2e7c7569ea59c89bd12bc61b79344c1210d80e1ea91e1"

COMPATIBLE_MACHINE = "(mx8)"
