require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=10c0fda810c63b052409b15a5445671a"

IMX_SRCREV_ABBREV = "bc7b6a2"

SRC_URI[md5sum] = "e6ac75617944d9a9dbba90f863f07e0f"
SRC_URI[sha256sum] = "5fe828113b9b2801b3fd60cd15eadfd0ac747e5897ef7db7fa22f80e7dd8a8e1"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
