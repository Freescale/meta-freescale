require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "28ef177f53be40c738f46018cebf055c"
SRC_URI[sha256sum] = "27ed3f58681cef18f87ea20946cc89b2cef4848006064303d20583e6ed7aeec7"

COMPATIBLE_MACHINE = "(mx8)"
