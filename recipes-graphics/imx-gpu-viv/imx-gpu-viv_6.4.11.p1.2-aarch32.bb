require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=63a38e9f392d8813d6f1f4d0d6fbe657"

IMX_SRCREV_ABBREV = "1e0c396"

SRC_URI[md5sum] = "ac711ff819a31602021b7700b41c1ecc"
SRC_URI[sha256sum] = "491ac012d691e27856769296e2334ad1b6f45e31ffe7313fcdb028c75b3b69ae"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
