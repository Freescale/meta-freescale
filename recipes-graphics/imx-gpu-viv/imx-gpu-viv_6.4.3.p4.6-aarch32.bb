# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "92d8a1440b680917a4001ebe65811584"
SRC_URI[sha256sum] = "fdb9e4250d2baf9a76ba60eab376c2317f9c53b621fe2c886a02f6355c0e01c6"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
