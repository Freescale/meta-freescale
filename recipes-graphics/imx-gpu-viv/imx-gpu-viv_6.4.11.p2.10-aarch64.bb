require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837" 

IMX_SRCREV_ABBREV = "accdd64"

SRC_URI[sha256sum] = "8108fd146de6986486f34860227511a5101b31072b99cd78ae38afba8939fd4e"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
