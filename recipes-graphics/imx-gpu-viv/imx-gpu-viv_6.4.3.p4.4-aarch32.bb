# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "5cf2085e4b9706e4c964ed7fdb57bfe3"
SRC_URI[sha256sum] = "5b9dd02cb2dfa564903872576cd6586fbf4a02abdb8e180978bd84205ab302a7"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
