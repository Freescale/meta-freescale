require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "d53371c1a9a504ff15f747e725164dcb"
SRC_URI[sha256sum] = "6106133afed40327b65d3eec0c197d214ff8f28f8ce3cad94653be4bffb9f9d4"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
