require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359"

IMX_SRCREV_ABBREV = "3c5e429"

SRC_URI[sha256sum] = "bf6fe102e8aa7a16373392efcf6ac45d705bbb95f5c39501da8aaa30957c554f"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
