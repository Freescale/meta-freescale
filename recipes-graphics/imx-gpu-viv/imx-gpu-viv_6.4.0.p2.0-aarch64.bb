require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "f4005a4a2dba6a79d8f25547612aa3b9"
SRC_URI[sha256sum] = "148e1b1a9e382a8159d5763dd2b08caad008eb931f3d925ac901c2438440d508"

COMPATIBLE_MACHINE = "(mx8)"
