require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "20cecb3e5440f63bb6612c740ccfe43a"
SRC_URI[sha256sum] = "283f2f51cadf5138bd47269a73425a51f69453556fb80f18521da04317e547a8"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
