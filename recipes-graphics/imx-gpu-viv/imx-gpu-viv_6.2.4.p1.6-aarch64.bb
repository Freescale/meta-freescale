require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "2d5437e5264a25fdddcc29c63db82e84"
SRC_URI[sha256sum] = "bfcb9f8f16b006c35576a57d185692ae22acdc9353b5a1f7f818436810224027"

COMPATIBLE_MACHINE = "(mx8)"
