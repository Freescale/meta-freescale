require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

IMX_SRCREV_ABBREV = "173c22a"

SRC_URI[md5sum] = "ac54634f6d9b1e20f99abd02ed433ef9"
SRC_URI[sha256sum] = "b28828549a75cfd5d86716e3697e9f770e1cef1e90e919b22ea3b1df5de821ca"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
