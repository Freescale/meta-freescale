require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

IMX_SRCREV_ABBREV = "8626797"

SRC_URI[sha256sum] = "db361e1f9db45f498fd669e1f58823d937d436e6fc797da6c710cf35609b47a9"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
