require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef4f968b9dae8ba406390cd617c2301d"

IMX_SRCREV_ABBREV = "ec0a6bb"

SRC_URI[sha256sum] = "1528d29e386d7cc173ce35bf26d20d6b308b29e3a4a55d54a6079b89b99315c4"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
