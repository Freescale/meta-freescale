require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

IMX_SRCREV_ABBREV = "173c22a"

SRC_URI[md5sum] = "73f3bb663ebb6b632d2cd19b4cb48eab"
SRC_URI[sha256sum] = "18f25c68db762953ccbf051fc3559ab8587fdcbf84e1248275f91f8bdc9853ec"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
