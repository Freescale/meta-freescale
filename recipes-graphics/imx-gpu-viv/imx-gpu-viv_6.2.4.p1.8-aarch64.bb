require imx-gpu-viv-6.inc

SRC_URI[md5sum] = "89cd1ad71128bc1b200c18a5a8db95b0"
SRC_URI[sha256sum] = "bf27b753b45777e90a158819d80d91f5226b34d71dc4ec4eea40f2c10c46159a"

COMPATIBLE_MACHINE = "(mx8)"
