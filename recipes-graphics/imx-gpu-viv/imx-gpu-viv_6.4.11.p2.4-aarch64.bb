require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

IMX_SRCREV_ABBREV = "b07999b"

SRC_URI[md5sum] = "142d9b9ef6f440b8e307569873bdb6b5"
SRC_URI[sha256sum] = "ba86656c357c5d9793058695f320e4cf650d4693e84321870bad392f2a622807"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
