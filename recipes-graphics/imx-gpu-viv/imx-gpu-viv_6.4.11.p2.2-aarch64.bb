require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"

IMX_SRCREV_ABBREV = "fd0148d"

SRC_URI[md5sum] = "b76784e04f24ec9f2bedf2dd377ed5a8"
SRC_URI[sha256sum] = "6e34f3718925ba37c362cd09a3228cc56d03cfad323ebae0932f64449dbaeb2e"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
