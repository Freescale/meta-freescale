# Copyright (C) 2012-2016 Freescale Semiconductor
# Copyright (C) 2012-2014 O.S. Systems Software LTDA.
# Released under the MIT license (see COPYING.MIT for the terms)

require xf86-video-imxfb-vivante.inc

SRC_URI += "file://Stop-using-Git-to-write-local-version.patch"

SRC_URI[md5sum] = "457b39733b34009754c36224dfd25ea1"
SRC_URI[sha256sum] = "00b4925819601461c0aa293a25024709410ab8d669accfa71ffd3177ff3cdeb2"
