COMPATIBLE_MACHINE_armv7ve = "(.*)"
