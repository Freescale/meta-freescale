# testbuild/../test.c:10: undefined reference to `glXCreateContext' 
PACKAGECONFIG:remove:imxgpu = "x11"
