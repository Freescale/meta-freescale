# install default weston.ini for IVI
WESTON_INI_INSTALL_FILE = "${B}/ivi-shell/weston.ini"
