# don't install default weston.ini
WESTON_INI_INSTALL_FILE = ""
