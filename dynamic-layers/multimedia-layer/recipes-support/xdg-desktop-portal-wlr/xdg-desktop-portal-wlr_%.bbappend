# Needs gbm_bo_create_with_modifiers2() API which is not
# implemented in imx GL driver implementation
COMPATIBLE_HOST:imxgpu = "(null)"
