# vivante drivers does not provide glx
PACKAGECONFIG:remove:imxgpu = "x11"
