# Copyright (C) 2013-2015 Freescale Semiconductor

include imx-test.inc

SRC_URI[md5sum] = "b5d156c4766f06135bfdbf83dc708373"
SRC_URI[sha256sum] = "a7c8aefb57c59883349cef755dc64b09b14af20e20a6a7554828cf6d7347b40e"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
