# Copyright (C) 2013-2015 Freescale Semiconductor

include imx-test.inc

SRC_URI[md5sum] = "38744ca0f85fb1ae8346ab9ac2030e54"
SRC_URI[sha256sum] = "22ffd80b445467e53758f3e1fd20556f8da9675a4c04ec59dcb6aee636e7f931"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7)"
