# Copyright (C) 2013-2015 Freescale Semiconductor

include imx-lib.inc

PE = "1"

SRC_URI[md5sum] = "d38daf723e270387ba41041f7b588ac4"
SRC_URI[sha256sum] = "0215acc97ca7e1c8dbdc2f1f9c7e85dae0725fdac56b79e8ec1c37e47a6d38a5"

COMPATIBLE_MACHINE = "(mx6|mx7)"
