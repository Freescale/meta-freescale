# Copyright (C) 2012-2015 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

SRC_URI[md5sum] = "1f19ffcbd6f8c3fcde271cf6f0314836"
SRC_URI[sha256sum] = "fd14c3666eb3c12f4f2665d95caf383bb1d0277bb12e2de28fefc8d1230604f2"

COMPATIBLE_MACHINE = "(mx5|mx6|mx6ul|mx7)"
