# Copyright (C) 2012-2015 Freescale Semiconductor

require firmware-imx.inc

SRC_URI[md5sum] = "543210d17971f61c7c1829d2c160dc4e"
SRC_URI[sha256sum] = "6c1a383d6f40ae79f7da85584fdf90a6718538bc87f02c3037bcd6b8cb748483"

COMPATIBLE_MACHINE = "(mx5|mx6)"
