# Copyright (C) 2012-2015 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

SRC_URI[md5sum] = "e466839e2cfbbcacb974b872c0b063e7"
SRC_URI[sha256sum] = "8cc2df128c0e2d2f5224d73389fbe6e4d6fa9ede76f8c0a9adaf7ec0986d0f1f"

COMPATIBLE_MACHINE = "(mx5|mx6|mx7)"
