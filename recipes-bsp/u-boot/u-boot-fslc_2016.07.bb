include u-boot-fslc.inc

PV = "v2016.07+git${SRCPV}"

SRCREV = "20b081a125ef7c59d6f74778a9cbd93439222383"
SRCBRANCH = "2016.07+fslc"
