include u-boot-fslc.inc

PV = "v2016.09+git${SRCPV}"

SRCREV = "157ec06ef780e3dac510f35b6fcf496c22fb24f9"
SRCBRANCH = "2016.09+fslc"
