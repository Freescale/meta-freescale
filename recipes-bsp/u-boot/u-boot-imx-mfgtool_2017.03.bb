# Copyright (C) 2014 O.S. Systems Software LTDA.
# Copyright (C) 2014-2016 Freescale Semiconductor
# Copyright 2017 NXP

require u-boot-imx_${PV}.bb
require u-boot-mfgtool.inc
