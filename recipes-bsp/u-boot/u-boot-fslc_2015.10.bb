include u-boot-fslc.inc

PV = "v2015.10+git${SRCPV}"

SRCREV = "982a6474ec320bcbd7513d7319e20d9ddb0f4cb0"
SRCBRANCH = "2015.10+fslc"
