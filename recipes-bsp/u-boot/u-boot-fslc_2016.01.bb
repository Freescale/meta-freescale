include u-boot-fslc.inc

PV = "v2016.01+git${SRCPV}"

SRCREV = "5da79530cef86a4e3a5e618b82f675da5bd3ca37"
SRCBRANCH = "2016.01+fslc"
