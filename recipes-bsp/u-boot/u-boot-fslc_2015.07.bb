include u-boot-fslc.inc

PV = "v2015.07+git${SRCPV}"

SRCREV = "31851bd6bd527b1c9275ea9597594f382779c679"
SRCBRANCH = "2015.07+fslc"
