include u-boot-fslc.inc

PV = "v2016.05+git${SRCPV}"

SRCREV = "31064626988e9ac242b76d3fcbd2091143796d8e"
SRCBRANCH = "2016.05+fslc"
