include u-boot-fslc.inc

PV = "v2017.03+git${SRCPV}"

SRCREV = "2b94a1cb2817e25c1b2655b9b4c6564f8e5d1b35"
SRCBRANCH = "2017.03+fslc"
