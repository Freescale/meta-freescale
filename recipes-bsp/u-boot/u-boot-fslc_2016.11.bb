include u-boot-fslc.inc

PV = "v2016.11+git${SRCPV}"

SRCREV = "854bc28b5e821477efb35a6eabfdebf8dcbaa2bb"
SRCBRANCH = "2016.11+fslc"
