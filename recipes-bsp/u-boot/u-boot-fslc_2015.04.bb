include u-boot-fslc.inc

PV = "v2015.04+git${SRCPV}"

SRCREV = "5d9ffd22149119c0acfd31efb8c4d40afca7ce6f"
SRCBRANCH = "patches-2015.04"
