include u-boot-fslc.inc

PV = "v2017.07+git${SRCPV}"

SRCREV = "65a6a14ccd0beb43376a9d0aec8fd171c6427063"
SRCBRANCH = "2017.07+fslc"
