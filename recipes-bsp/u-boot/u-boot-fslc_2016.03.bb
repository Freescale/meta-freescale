include u-boot-fslc.inc

PV = "v2016.03+git${SRCPV}"

SRCREV = "fd6b196f574ca85d75d6bbe24cf9344e58366ae1"
SRCBRANCH = "2016.03+fslc"
