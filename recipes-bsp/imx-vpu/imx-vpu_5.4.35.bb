# Copyright (C) 2013-2016 Freescale Semiconductor

require imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=8cf95184c220e247b9917e7244124c5a"

PE = "1"

SRC_URI[md5sum] = "52c1ee80c11d3179715c932f3f3ae890"
SRC_URI[sha256sum] = "e1d6550426dfc59e4fd0352f1d312ea7eff5dcf18974f923ed7a85007cb40e27"

COMPATIBLE_MACHINE = "(mx6)"
