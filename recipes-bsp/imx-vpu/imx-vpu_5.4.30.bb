# Copyright (C) 2013-2015 Freescale Semiconductor

require imx-vpu.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

PE = "1"

SRC_URI[md5sum] = "1e48e8367478c86ffd06b6330b50a678"
SRC_URI[sha256sum] = "43f613fcc0e40abdb69ba9fcf3ac49649b1a6f84ee7c79fe262e0faac072d8e6"

COMPATIBLE_MACHINE = "(mx6)"
