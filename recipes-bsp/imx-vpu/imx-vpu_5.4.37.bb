# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP

require imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6b552f505eedab4a11ab538cf3db743a"

PE = "1"

SRC_URI[md5sum] = "2b8311cb6e5b5813253db706e807d962"
SRC_URI[sha256sum] = "ee265e88d17c7369bd9cb917e7cce035b8c7ee2ba4491645fdab9f382f54beb0"

COMPATIBLE_MACHINE = "(mx6)"
