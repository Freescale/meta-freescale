# Copyright (C) 2013-2015 Freescale Semiconductor

require imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

PE = "1"

SRC_URI[md5sum] = "d7bfe9f96169f4637327436a4e848dae"
SRC_URI[sha256sum] = "f11b91dcdb84bfefd3c88f10a9c1c1bc3420e4bbaadc38b9280fb52f7769eca8"

COMPATIBLE_MACHINE = "(mx6)"
