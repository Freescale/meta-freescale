require optee-client.nxp.inc

OPTEE_CLIENT_BRANCH = "lf-6.12.20_2.0.0"
SRCREV = "02e7f9213b0d7db9c35ebf1e41e733fc9c5a3f75"
