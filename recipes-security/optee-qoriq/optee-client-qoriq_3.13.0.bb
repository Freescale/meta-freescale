require optee-client.nxp.inc

PV:append = "+git${SRCPV}"

COMPATIBLE_MACHINE = "(qoriq-arm64)"
