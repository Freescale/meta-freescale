require optee-client.nxp.inc

OPTEE_CLIENT_BRANCH = "lf-6.12.49_2.2.0"
SRCREV = "7443d47f9468a38721cec802bed5ba4222690697"
