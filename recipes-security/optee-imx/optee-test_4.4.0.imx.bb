# Copyright 2017-2024 NXP

require optee-test-fslc-imx.inc

# The BSD and GPL license files are now included in the source
# https://github.com/OP-TEE/optee_test/commit/a748f5fcd9ec8a574dc86a5aa56d05bc6ac174e7
LIC_FILES_CHKSUM = "file://LICENSE.md;md5=a8fa504109e4cd7ea575bc49ea4be560 \
                    file://LICENSE-BSD;md5=dca16d6efa93b55d0fd662ae5cd6feeb \
                    file://LICENSE-GPL;md5=10e86b5d2a6cb0e2b9dcfdd26a9ac58d"


SRCBRANCH = "lf-6.6.52_2.2.0"
SRCREV = "dafc98ed8364d7281a9a7f0788dd0a2067844a59"
