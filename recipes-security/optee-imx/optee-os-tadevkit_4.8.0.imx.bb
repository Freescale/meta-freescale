require optee-os-tadevkit-fslc-imx.inc

SRCBRANCH = "lf-6.18.2_1.0.0"
SRCREV = "e7ed997213779e3d1b7417461c5b4847d3230db9"
