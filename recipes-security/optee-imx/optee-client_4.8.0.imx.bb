require optee-client-fslc-imx.inc

SRCBRANCH = "lf-6.18.2_1.0.0"
SRCREV = "ad79099ca6b642f2bb69739f020ea50698ea0744"
