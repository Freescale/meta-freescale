require optee-os-tadevkit-fslc-imx.inc

SRCBRANCH = "lf-6.18.37_2.1.0"
SRCREV = "99f40897dd1fc28b4c792773b167e3db629db2ff"
