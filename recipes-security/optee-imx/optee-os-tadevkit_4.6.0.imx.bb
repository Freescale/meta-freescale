require optee-os-tadevkit-fslc-imx.inc

SRCBRANCH = "lf-6.12.20_2.0.0"
SRCREV = "87964807d80baf1dcfd89cafc66de34a1cf16bf3"
