require optee-client-fslc-imx.inc

SRCBRANCH = "lf-6.18.37_2.1.0"
SRCREV = "0a2b1e95ba338b79c2a96cd343a96ea3e6157cb0"
