# Copyright 2017-2024,2026 NXP

require optee-os-fslc-imx.inc

SRCBRANCH = "lf-6.18.20_2.0.0"
SRCREV = "37c7fbf84c40eb9e5828532972ffb133b4917390"
