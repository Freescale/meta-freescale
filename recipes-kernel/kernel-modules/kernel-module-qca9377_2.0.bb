require kernel-module-qcacld-lea.inc

SUMMARY = "Qualcomm WiFi driver for QCA module 9377"

EXTRA_OEMAKE += "${EXTRA_OEMAKE_QCA9377}"
