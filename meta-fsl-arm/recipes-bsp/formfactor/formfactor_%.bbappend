# Append path for freescale to include costom matchconfig
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
