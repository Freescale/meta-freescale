include imx-test.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "422f08ae12c084a2e6b213a034588318"
SRC_URI[sha256sum] = "410cb1b1942eefb7b6beee9a0554cf65c8c5fc4069d88f1ac2eda22b3edb655c"

COMPATIBLE_MACHINE = "(mx6)"
