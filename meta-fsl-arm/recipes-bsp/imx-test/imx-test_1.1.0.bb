include imx-test.inc

PR = "${INC_PR}.0"
PE = "1"

SRC_URI[md5sum] = "131d4bc51150640f96fa3aca76035f33"
SRC_URI[sha256sum] = "8605e103c9feb1e06f1edbfdb65e92e60e25a3fb88c9abcfbef6191ac3f08d7d"

COMPATIBLE_MACHINE = "(mx6)"
