# Copyright (C) 2013 Freescale Semiconductor

require imx-test.inc

PE = "1"

SRC_URI[md5sum] = "98788357991eb5b3af289d8084199b48"
SRC_URI[sha256sum] = "eefb26ed66d4ff53cf3467182e8916c02efa847e69321c90d5b6ef65bf1ee665"

COMPATIBLE_MACHINE = "(mx6)"
