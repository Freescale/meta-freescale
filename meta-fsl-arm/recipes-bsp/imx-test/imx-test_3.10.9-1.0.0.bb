# Copyright (C) 2013 Freescale Semiconductor

include imx-test.inc

PE = "1"

SRC_URI[md5sum] = "518ce3fba668a09993d53b3b0df85944"
SRC_URI[sha256sum] = "576ffd963cc8ea82e6f17e55ac467448286df014408b23a59ecf9d8072955d7a"

COMPATIBLE_MACHINE = "(mx6)"
