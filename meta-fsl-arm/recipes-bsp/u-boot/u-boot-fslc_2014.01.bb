include u-boot-fslc.inc

PV = "v2014.01"

SRCBRANCH = "patches-2014.01"

SRCREV = "490069b30d013a7d35ce7fe37b1ecd53f6c8e352"
