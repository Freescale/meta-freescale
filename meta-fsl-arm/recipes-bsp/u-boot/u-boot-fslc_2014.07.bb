include u-boot-fslc.inc

PV = "v2014.07"

SRCREV = "524123a70761110c5cf3ccc5f52f6d4da071b959"
SRCBRANCH = "patches-2014.07"
