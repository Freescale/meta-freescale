include u-boot-fslc.inc

PV = "v2015.04+git${SRCPV}"

SRCREV = "b16ec2de8ddd3ce3bca7566e045dc085755550f6"
SRCBRANCH = "patches-2015.04"
