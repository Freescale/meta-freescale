include u-boot-fslc.inc

PV = "v2015.01+git${SRCPV}"

SRCREV = "3120db4e15698a7cf8330473d5da83e44e593e9e"
SRCBRANCH = "patches-2015.01"
