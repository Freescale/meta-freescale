# Copyright (C) 2013-2015 Freescale Semiconductor

include imx-lib.inc

PE = "1"

SRC_URI[md5sum] = "c510512ebd2bae5a7e57079b9788960e"
SRC_URI[sha256sum] = "4db2c1f286f2478b8236e62de4df9d2a2c26ff727c752dc4f21e2910f4a5e5d7"

COMPATIBLE_MACHINE = "(mx6)"
