# Copyright (C) 2013 Freescale Semiconductor

include imx-lib.inc

SRC_URI[md5sum] = "5cc9c8d09c7ba401cdab4a2ecbda89e2"
SRC_URI[sha256sum] = "d1581c2f2956731da0c42e9dc17514a4d00790deeb83defeb5e07d14746190d8"

PE = "1"

COMPATIBLE_MACHINE = "(mx6)"