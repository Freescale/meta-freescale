# Copyright (C) 2013-2015 Freescale Semiconductor

require imx-vpu.inc

PE = "1"

SRC_URI[md5sum] = "3dc36b427fc2b91af05504f39f8f964f"
SRC_URI[sha256sum] = "e4e983f465c2ed296908dfe2bfcff2890c8f05b38f6ae98e7a7879b23a2b1a4e"

COMPATIBLE_MACHINE = "(mx6)"
