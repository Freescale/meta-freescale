# Copyright (C) 2013-2015 Freescale Semiconductor

require imx-vpu.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

PE = "1"

SRC_URI[md5sum] = "774455b57aaa12bae2e2cecf39b63ac4"
SRC_URI[sha256sum] = "0a05af1a5978175de852b2cf61763ec789f2845df78edb8d02a28611439b57f7"

COMPATIBLE_MACHINE = "(mx6)"
