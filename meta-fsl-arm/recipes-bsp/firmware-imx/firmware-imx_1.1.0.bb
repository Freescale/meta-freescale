require firmware-imx.inc

PR = "${INC_PR}.0"
PE="1"

SRC_URI[md5sum] = "6eeccfdadd01f84197f3c41cf6df729b"
SRC_URI[sha256sum] = "d17a7bdfd9c1c0fdff13ec73044f2832d8b64ab5b26e71c86a876c7c86e82eae"

COMPATIBLE_MACHINE = "(mx6)"
