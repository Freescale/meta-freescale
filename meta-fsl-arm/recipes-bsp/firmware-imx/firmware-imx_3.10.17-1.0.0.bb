# Copyright (C) 2012-2014 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

PE="1"

SRC_URI[md5sum] = "29a54f6e5bf889a00cd8ca85080af223"
SRC_URI[sha256sum] = "768d857dfc1bec344fbd95665e450030d5a0d541a695027f6d7815e0309bea37"

COMPATIBLE_MACHINE = "(mx6)"
