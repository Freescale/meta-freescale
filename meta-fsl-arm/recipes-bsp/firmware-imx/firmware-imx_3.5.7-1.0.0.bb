# Copyright (C) 2012-2013 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

PE="1"

SRC_URI[md5sum] = "7285345d99e1064bdbad113e3d9b8f40"
SRC_URI[sha256sum] = "f7d2fa619b6ea73010adcd21ff1b6296d337d3fa5e6f887860e52b42e281f6e4"

COMPATIBLE_MACHINE = "(mx6)"
