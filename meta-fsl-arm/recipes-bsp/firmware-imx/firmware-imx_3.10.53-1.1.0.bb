# Copyright (C) 2012-2015 Freescale Semiconductor

require firmware-imx.inc

PE="1"

SRC_URI[md5sum] = "b15ce0e8d2acb4ad694d7c0b835678ef"
SRC_URI[sha256sum] = "32391ce725657a74d69c448556c62afc3d3dafed55aa1a20de257a07171cb151"

COMPATIBLE_MACHINE = "(mx5|mx6)"
