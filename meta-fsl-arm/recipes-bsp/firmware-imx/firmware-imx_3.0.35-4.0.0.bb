require firmware-imx.inc

PR = "${INC_PR}.0"
PE="1"

SRC_URI[md5sum] = "f23ce8437e141c1d20e3bf175eb3af7f"
SRC_URI[sha256sum] = "5aaf5e91dbec8072fec613218c0fc939d9a59e74df53054f49ab31f1f0dd25d9"

COMPATIBLE_MACHINE = "(mx6)"
