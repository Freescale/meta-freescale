require firmware-imx.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "973fde728ab6e6be1d02954051233141"
SRC_URI[sha256sum] = "6836ef21b0649670c8f0a0f3388f08dba620c6dea73fdf918959b3e5f965bc66"

COMPATIBLE_MACHINE = "(mx6)"
