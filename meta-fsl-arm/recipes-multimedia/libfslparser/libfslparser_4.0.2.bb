# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "3ac0d341003ffe8404fd84e36b23dc5a"
SRC_URI[sha256sum] = "541dbc5d05becc379d9101b28f84802532b4591e417f3522ed7fb8f2c3a55950"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6)"
