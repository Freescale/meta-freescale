# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "5306fbcd174fb18328a6ccf87bf55953"
SRC_URI[sha256sum] = "7d63e4a73c90021e7d12860749d78679e1932bdce8c988f0183018366b6afd06"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6)"
