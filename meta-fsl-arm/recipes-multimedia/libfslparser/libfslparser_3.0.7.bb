# Copyright (C) 2012-2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

SRC_URI[md5sum] = "320f6fd4bb45780e0e2b12ccce26113c"
SRC_URI[sha256sum] = "292c16d2a2e4159c97ef720cfb89900f4fa606e0e9220e0734f4251265638bc2"

COMPATIBLE_MACHINE = "(mx28|mx5|mx6)"
