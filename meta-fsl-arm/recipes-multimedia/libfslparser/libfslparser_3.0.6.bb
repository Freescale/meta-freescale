# Copyright (C) 2012-2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslparser.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "eec29f1148f1e58fcceac11b2019280d"
SRC_URI[sha256sum] = "37c5ba29e2c68636d20a48cf743098ea2f490566af19a13db6da221a2792254b"

COMPATIBLE_MACHINE = "(mx28)"
