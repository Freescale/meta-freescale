include imx-lib.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1ec3b9bcfaf9c0eba4babc2a3b56a5bb"
SRC_URI[sha256sum] = "9af3d62f70f1efcecd62eadb4d79ded64a699ca9e162c7494c51eb7afee0810d"

COMPATIBLE_MACHINE = "(mx6)"
