# Copyright (C) 2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "03bddd43219b4dea4f0e0fcdfed32ade"
SRC_URI[sha256sum] = "f42c63350b76397620d05c2b1c73506af07012d93191d5acbe82f8fb3d551b89"

COMPATIBLE_MACHINE = "(mx28|mx5|mx6)"
