# Copyright (C) 2012-2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "dc08b569175981fc0bd5f97986cfd543"
SRC_URI[sha256sum] = "2a4a7248246ff37f30486f34918151f09493ecfcaeca0cd8155d5b5c93245138"

COMPATIBLE_MACHINE = "(mx6)"
