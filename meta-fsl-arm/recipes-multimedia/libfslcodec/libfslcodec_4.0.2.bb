# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "a89ffc781292c56d4664f1ec67331243"
SRC_URI[sha256sum] = "d5baa92fefe68f7456380172fefc14ec9e4c155e1d2f6672c23bc5e06841bd1a"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6)"
