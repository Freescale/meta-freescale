# Copyright (C) 2013 Freescale Semicondutors
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "349bc30abbec37f78c167d99cfb5ee7b"
SRC_URI[sha256sum] = "899547c2a02a958b792785fe3396f30d6dfb4bb3833f3cd386e0dbe94edae422"

COMPATIBLE_MACHINE = "(mx28)"
