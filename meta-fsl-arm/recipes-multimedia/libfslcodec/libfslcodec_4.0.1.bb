# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require libfslcodec.inc

SRC_URI[md5sum] = "6f41d660de351a6cbc8dabe67e1a4774"
SRC_URI[sha256sum] = "ea135ccb3c8b24c1a73ec8c6085a57e03dc721903a8c717a9b9781030471d5a7"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6)"
