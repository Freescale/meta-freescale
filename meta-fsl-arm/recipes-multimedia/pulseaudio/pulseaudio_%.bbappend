
CACHED_CONFIGUREVARS_append_mx6 = " ax_cv_PTHREAD_PRIO_INHERIT=no"

PACKAGE_ARCH_mx6 = "${MACHINE_SOCARCH}"
