#Remove gles2 as it is not supported by sololite

PACKAGECONFIG_remove_mx6sl = "gles2"
