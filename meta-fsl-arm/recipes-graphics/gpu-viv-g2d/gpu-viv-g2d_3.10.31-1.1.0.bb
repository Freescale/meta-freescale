# Copyright (C) 2013, 2014 Freescale Semiconductor

include gpu-viv-g2d.inc

SRC_URI[md5sum] = "0e19e7ff3d8a98aa8fd58bd03a633723"
SRC_URI[sha256sum] = "6957fb7ab86858c008c531fb620a30cf8d7f7734999a34852534920bc36a365a"
