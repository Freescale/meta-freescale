# Copyright (C) 2013 Freescale Semiconductor

include gpu-viv-g2d.inc

LIC_FILES_CHKSUM = "file://usr/include/g2d.h;endline=7;md5=861ebad4adc7236f8d1905338abd7eb2"

SRC_URI[md5sum] = "3d9849a60cb488a906aeb14f966effad"
SRC_URI[sha256sum] = "9c29b602626961f9ab93a6231c2de55cde406629ec94c4348cb2048056926195"

