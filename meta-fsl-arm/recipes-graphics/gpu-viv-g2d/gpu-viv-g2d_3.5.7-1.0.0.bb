# Copyright (C) 2013 Freescale Semiconductor

include gpu-viv-g2d.inc

LIC_FILES_CHKSUM = "file://usr/include/g2d.h;endline=7;md5=861ebad4adc7236f8d1905338abd7eb2"

SRC_URI[md5sum] = "cb1939d1de300bbe334e6e8e0137ae57"
SRC_URI[sha256sum] = "460d0df171766edbea1fe6781a38346596ad13f748eb971296c04c261cec5450"

