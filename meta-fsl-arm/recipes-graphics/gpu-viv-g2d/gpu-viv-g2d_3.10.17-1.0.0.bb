# Copyright (C) 2013, 2014 Freescale Semiconductor

include gpu-viv-g2d.inc

SRC_URI[md5sum] = "1dd925c48d36b7029d9fe2522d0700c7"
SRC_URI[sha256sum] = "c9ec4b0daa476ff02b2964998a113f53a85f4d9606c4ec617858f33cab2af203"
