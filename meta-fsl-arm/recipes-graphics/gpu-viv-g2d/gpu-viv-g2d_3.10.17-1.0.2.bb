# Copyright (C) 2013, 2014 Freescale Semiconductor

include gpu-viv-g2d.inc

SRC_URI[md5sum] = "82d1418c06ca46e4e51deea2749c14d8"
SRC_URI[sha256sum] = "585a19071d9801a02178b94434c8f6393fa59cd361e96b2721bb20562d287d28"
