# Set i.MX specific dependencies and device type
DEPENDS += "virtual/libgles2"
EGLINFO_DEVICE = "imx6"
