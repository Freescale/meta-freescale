# Set i.MX specific dependencies and device type
EGLINFO_DEVICE_mx6 = "imx6"
