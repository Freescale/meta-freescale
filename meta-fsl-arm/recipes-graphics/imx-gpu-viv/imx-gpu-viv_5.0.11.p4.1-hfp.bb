# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

SRC_URI[md5sum] = "dd2093e6ec951fe843a2944af307d721"
SRC_URI[sha256sum] = "6c436ea127bc1423fbe092ee5eaa3a8513647dfe2aff79f446fa8d6b4d00bcac"

PACKAGE_FP_TYPE = "hardfp"
