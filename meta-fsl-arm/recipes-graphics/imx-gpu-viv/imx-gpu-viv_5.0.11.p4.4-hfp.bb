# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

SRC_URI[md5sum] = "5aa3dfe5b9362f9ee53615e0a56f9009"
SRC_URI[sha256sum] = "92654c185835e139cc9485806ad184fdac21f4d640ec9d0e493669235d21de9b"

PACKAGE_FP_TYPE = "hardfp"
