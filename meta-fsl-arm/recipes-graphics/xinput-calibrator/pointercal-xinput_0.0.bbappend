# Append path for freescale layer to include bsp pointercal.xinput
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
