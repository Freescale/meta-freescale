# We use 1.11.4 Xorg version for i.MX6 and it has different ABI so
# make it machine specific
PACKAGE_ARCH_mx6 = "${MACHINE_ARCH}"
