PRINC := "${@int(PRINC) + 2}"

PROVIDES_mx5 = "virtual/libgl"
PROVIDES_mx6 = "virtual/libgl"

PACKAGE_ARCH_mx5 = "${MACHINE_ARCH}"
PACKAGE_ARCH_mx6 = "${MACHINE_ARCH}"
