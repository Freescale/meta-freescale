PRINC := "${@int(PRINC) + 1}"

PROVIDES_mx5 = "virtual/libgl"

PACKAGE_ARCH_mx5 = "${MACHINE_ARCH}"
