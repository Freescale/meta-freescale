# Copyright (C) 2013 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "1ff2249a2633635ea8c375d9e83ca520"
SRC_URI[sha256sum] = "b0e3c84f749aac3dab4ec328d19dbd3bba06ccc6ef8b7d4eefe3d79474be5055"

PACKAGE_FP_TYPE = "softfp"
