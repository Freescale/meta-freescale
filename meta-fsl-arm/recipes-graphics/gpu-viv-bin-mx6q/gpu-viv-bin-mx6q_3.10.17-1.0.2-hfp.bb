# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "d3080f644f65446e682d79c36ad1616d"
SRC_URI[sha256sum] = "d480546638b39d37b7e571d131b480a2f2f0380299ea6b2b691a02b2173ea273"

PACKAGE_FP_TYPE = "hardfp"
