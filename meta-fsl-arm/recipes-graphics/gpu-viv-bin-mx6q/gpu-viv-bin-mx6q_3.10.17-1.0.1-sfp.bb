# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "55788f48a222b430a8b76856ac6fa636"
SRC_URI[sha256sum] = "0d9069635c97424117896e532c7e5a7be6e699482bc9fb6d8fc1ba946043da19"

PACKAGE_FP_TYPE = "softfp"
