# Copyright (C) 2012 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

PR = "${INC_PR}.0"

include gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "9f2c43b6eae468df6cc6fd75efd00bc5"
SRC_URI[sha256sum] = "2cec10c1d69bce75a7c2a4482eb3ed29b171578c3b01c5b4ef2cc868ca327330"
