# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "8eb1c16e514a8727614d6167799a4495"
SRC_URI[sha256sum] = "df70d763e433dffaa51da0f4a9f38b40d5b42ef89e8efeab928414dd746c0b89"

PACKAGE_FP_TYPE = "softfp"
