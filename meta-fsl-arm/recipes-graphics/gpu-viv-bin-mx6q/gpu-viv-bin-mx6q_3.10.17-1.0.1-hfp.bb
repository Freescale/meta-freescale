# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "d729db01e3eec3384e310cd3507761ce"
SRC_URI[sha256sum] = "0d71029e561b94bc14a0039eeaabec1610d5244ccaf0e77356f0eee80cba828d"

PACKAGE_FP_TYPE = "hardfp"
