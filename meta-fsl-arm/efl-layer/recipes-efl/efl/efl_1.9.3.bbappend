FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-preprocessor-definitions-for-Vivante-GLES-header.patch"
