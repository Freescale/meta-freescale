PRINC := "${@int(PRINC) + 1}"

IMAGE_INSTALL += " \
    elftosb-nativesdk \
    mxsldr-nativesdk \
"
