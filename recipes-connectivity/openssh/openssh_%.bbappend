PACKAGECONFIG:mx6-nxp-bsp ??= ""
PACKAGECONFIG:mx7-nxp-bsp ??= ""
PACKAGECONFIG:mx8-nxp-bsp ??= ""
